Commit message: added updated work to main

File: ur_description/urdf/ur5_robotiq.urdf (robot description, URDF)
Before this commit: robot ur5, 21 links, 20 joints
Links:
- link robotiq_arg2f_base_link: mass 0.22652 -> 2.2652
